## config/boards/shields/chocofi_knob/Kconfig.defconfig
```kconfig
if SHIELD_CHOCOFI_KNOB

config ZMK_KEYBOARD_NAME
    default "Chocofi Knob"

config ZMK_USB
    default y

endif
```
